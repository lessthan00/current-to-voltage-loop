# Repository lessthan00/current-to-voltage-loop

File README.md:

# current-to-voltage-loop  

[采用 HART® 调制解调器的高精度环路供电式 4mA 至 20mA 现场变送器参考设计](https://www.ti.com.cn/tool/cn/TIDA-01504)  
  
器件OPA2244UA,NPN三极管  
  
OPA2244UA  
IQ 50uA/channl  
单位增益稳定  
V = +2.6V~+36V(单电源)  
Vs 1.5mV  
IB -2.5nA  
en 22nV/√Hz@1Khz  
GBW 430KHZ  
SR –0.1/+0.16V/µs  
  
NPN三极管 SOT-23-3或者SOT-89-3封装  
比如BCX54  
https://www.jlc-smt.com/lcsc/detail?componentCode=C475647  
collector 集电极  
base 基极  
emitter 发射极  
power dissipation 功率耗散  
breakdown voltage 击穿电压  
cut-off current 截止电流  
DC current gain 直流电流增益  
saturation voltage 饱和电压  
peak base current 基极峰值电流  
peak collector current 集电极峰值电流  
transition frequency 过渡频率  
  
关键参数:  
Vceo 45V > 36V 不会被击穿  
IC 1A > 20mA 不会过流  
PD 1.3W > 600mW 可以36V直接输入  
ICBO 集电极截止电流 100nA << 4mA 不会影响电流信号输出  
hFE 直流电流增益 25~250, 这是对设计的限制  
Vce(sat) 饱和电压 0.5V 对设计的限制  
VBE 开启电压 1V 这是对设计的限制  
  
4mA~20mA电流环路设计 V-I转换器  
  
深度负反馈回路 OPA(IN-)->OPA(OUT)->NPN(B)->NPN(E)->Re->GND->OPA(IN-).  
NPN 一直工作在放大区域, VB 恒大于NPN(Vbe), 同时 VE > VB, 结果是 Ic = (hFE)Ib  
  
当深度反馈建立后 VOPA(IN+) = VOPA(IN-) = VGND  
  
Id * Rd = Ic * Rc -> Id = Ic * Rc / Rd  
  
此时 Ic = vref / Rb + VDAC / Ra  
  
Iloop = Id + Ic = (1 + Rc / Rd) * Ic = (1 + Rc / Rd) * (vref / Rb + VDAC / Ra  
  
V-I 增益为 gain = (1 + Rc / Rd)  
  
具体电阻值可以通过python来计算  
  
BUSvoltage = LDO-VIN(min) + 2x0.7V + (Rload + Rd) * Iloop(max)  
一般取 Rload = 250R 2x0.7V(三极管正向偏置电压)  
  
LDO 可以加上限流电阻(200R)改善整体接收器阻抗  
  
NPN工作在放大区域, VCE > VBE > 0.7V   
  
Re < Vb(max)/ 20mA  
  
BUS voltage = Vce + (Rd + Re + Rload) * 20mA + 2x0.7V  
  
同时通过LTspice仿真发现, Re 过小会导致Vb过小,不能驱动NPN  
  
NPN的限流电阻取1K即可.

## KiCad design current-to-voltage-loop.kicad_pcb

Parts:
C1: 10nF; C_1206_3216Metric
C2: 300pF; C_1206_3216Metric
C3: 100nF; C_1206_3216Metric
C4: 1nF; C_1206_3216Metric
D1: MB6F; Diode_Bridge_MBF
D2: P4SMAJ36CA; D_SMA_TVS
FB1, FB2: 600R@100Mhz; L_1206_3216Metric
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
Q1: Q_NPN_BCE; SOT-89-3_BigPads
Q2: Q_NPN_Generic_BEC; SOT-23-3
R1: 10K; R_1206_3216Metric
R2: Ra; R_1206_3216Metric
R3: Rb; R_1206_3216Metric
R4: Rc; R_1206_3216Metric
R5: Rd; R_1206_3216Metric
R6: 250R; R_1206_3216Metric
R7: 1K; R_1206_3216Metric
R8: Re; R_1206_3216Metric
U1: OPA2244UA; SO-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.1, C3.1, J3.2, R3.2, U1.8 (V+)
/B: Q1.1 (B), Q2.1 (B), R7.1
/C: C2.1, D1.1 (+), J3.3, Q1.2 (C), Q2.3 (C)
/E: Q1.3 (E), Q2.2 (E), R8.2
/FLOAT: C2.2, D1.2 (-), R4.1, R5.1
/loop+: J1.2, J3.6, R6.1
/loop-: D2.1 (K), FB2.2, J3.5
DAC_OUT: J3.4, U1.3 (+)
GND: C1.2, C3.2, J3.1, R5.2, R8.1, U1.4 (V-), U1.6 (-)
unnamed: C4.2, D1.3 (1), FB2.1
unnamed: C4.1, D1.4 (2), FB1.1
unnamed: D2.2 (A), FB1.2, J1.1, R6.2
unnamed: R1.2, R2.1, U1.1
unnamed: R7.2, U1.7
unnamed: R1.1, U1.2 (-)
unnamed: R2.2, R3.1, R4.2, U1.5 (+)

Notes on the sheet:
SOT-23-3封装备用
250R 测试时用

Board: 2 copper layers, 36.0 x 34.0 mm, 21 parts (0 on the bottom side), 16 nets.
